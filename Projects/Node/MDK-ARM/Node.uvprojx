# Keil uVision project Node.uvprojx, settings and files
target MicroBit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF51822 BOARD_MICROBIT BSP_DEFINES_ONLY ESB_PRESENT NRF51
  c include: ..\;..\..\..\components;..\..\..\components\boards;..\..\..\components\drivers_nrf\common;..\..\..\components\drivers_nrf\delay;..\..\..\components\drivers_nrf\hal;..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\components\drivers_nrf\uart;..\..\..\components\libraries\bsp;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\util;..\..\..\components\proprietary_rf\esb;..\..\..\components\toolchain;..\..\..\external\segger_rtt;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo
  asm define: NRF51422 BOARD_PCA10028 BSP_DEFINES_ONLY ESB_PRESENT NRF51
  asm misc: --cpreproc_opts=-DNRF51422,-DBOARD_PCA10028,-DBSP_DEFINES_ONLY,-DESB_PRESENT,-DNRF51
  asm include: ..\..\..\config\esb_low_power_ptx_pca10028;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\proprietary_rf\esb;..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../: main.c sdk_config.h
  group Board Definition
    ../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Properitary_RF
    ../../../components/proprietary_rf/esb/: nrf_esb.c
  group nRF_Segger_RTT
    ../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
target Puck (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF51822 BOARD_PUCK BSP_DEFINES_ONLY ESB_PRESENT NRF51
  c include: as above
  asm define: NRF51422 BOARD_PCA10028 BSP_DEFINES_ONLY ESB_PRESENT NRF51
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
